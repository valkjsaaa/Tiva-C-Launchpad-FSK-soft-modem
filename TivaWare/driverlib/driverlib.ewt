<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Source</name>
    <file>
      <name>$PROJ_DIR$\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\comp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\cpu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\eeprom.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\fpu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hibernate.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\interrupt.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\mpu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\pwm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\qei.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ssi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\sysctl.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\sysexc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\systick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\udma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\usb.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\watchdog.c</name>
    </file>
  </group>
</project>


